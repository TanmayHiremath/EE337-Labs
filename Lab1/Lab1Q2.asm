ORG 00H
MOV 40H, #7FH
MOV 41H, #7EH
MOV 42H, #7DH
MOV 43H, #7CH
MOV 44H, #7BH
MOV 45H, #7AH
MOV 46H, #79H
MOV 47H, #78H
MOV 48H, #77H
MOV 49H, #76H
MOV 4AH, #75H
MOV 4BH, #74H
MOV 4CH, #73H
MOV 4DH, #72H
MOV 4EH, #71H
MOV 4FH, #70H
MOV 50H, #6FH
MOV 51H, #6EH
MOV 52H, #6DH
MOV 53H, #6CH
MOV R1,#40H
MOV R2,#00H
MOV R5,#14H
loop:MOV A,@R1
MOV R4,A
CLR C
SUBB A,R2
INC R1
JC label1
MOV A,R4
MOV R2,A
MOV A,R1
MOV R6,A
DEC R6
label1: DJNZ R5,loop


MOV R1,#40H
MOV R3,#00H
MOV R5,#14H
loop2:MOV A,R1
XRL A,R6
JNZ label2
INC R1
label2:CLR C
MOV A,@R1
MOV R4,A
SUBB A,R3
INC R1
JC label3
MOV A,R4
MOV R3,A
label3: DJNZ R5,loop2
MOV 70H,R2
MOV 71H,R3
END