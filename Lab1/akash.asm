ORG 00H

MOV 40H, #00H
MOV 41H, #01H
MOV 42H, #02H
MOV 43H, #03H
MOV 44H, #04H
MOV 45H, #05H
MOV 46H, #06H
MOV 47H, #07H
MOV 48H, #08H
MOV 49H, #09H
MOV 4AH, #0AH
MOV 4BH, #0BH
MOV 4CH, #0CH
MOV 4DH, #0DH
MOV 4EH, #0EH
MOV 4FH, #0FH
MOV 50H, #10H
MOV 51H, #11H
MOV 52H, #12H
MOV 53H, #13H
MOV 54H, #14H


MOV R1,#40H
MOV R2,#00H
MOV R7,#14H

LOOP:MOV A,@R1
MOV R4,A
CLR C
SUBB A,R2

JC STEP1
MOV A,R4
MOV R2,A
MOV A,R1
MOV R5,A
STEP1: INC R1
DJNZ R7,LOOP


MOV R1,#40H
MOV R3,#00H
MOV R7,#13H

LOOP2:MOV A,R1
XRL A,R5
JNZ STEP2
INC R1

STEP2:CLR C
MOV A,@R1
MOV R4,A
SUBB A,R3


JC STEP3
MOV A,R4
MOV R3,A
STEP3: INC R1
DJNZ R7,LOOP2
MOV 70H,R2
MOV 71H,R3
END