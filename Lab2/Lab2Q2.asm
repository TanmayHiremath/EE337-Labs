MOV 60H, #04H
MOV 61H, #01H
MOV 62H, #00H
MOV 63H, #00H
MOV 64H, #00H
MOV 65H, #00H
MOV 66H, #01H
MOV 67H, #00H
MOV 68H, #00H
MOV 69H, #00H
MOV 6AH, #03H
MOV 6BH, #00H
MOV 6CH, #01H
MOV 6DH, #00H
MOV 6EH, #00H
MOV 6FH, #01H
MOV 70H, #01H





MOV 11H,#40H
MOV 10H,#60H
MOV R2,60H
loop: MOV R3,60H
loop2:MOV A,R3
DEC A
MOV B,60H
MUL AB
ADD A,10H
ADD A,R2
MOV R0,A
MOV A,@R0
MOV R4,A


MOV A,R2
DEC A
MOV B,60H
MUL AB
ADD A,11H
ADD A,R3
MOV R1,A
MOV A,R4
MOV @R1,A
DJNZ R3,loop2
DJNZ R2,loop

MOV R1,#41H
MOV R0,#61H
MOV R2,60H
loop3:MOV A,@R1
MOV R4,A
MOV A,@R0
CJNE A,04H,finish
INC R0
INC R1
DJNZ R2,loop3
SETB PSW.5
LJMP here
finish:CLR PSW.5
here:sjmp here
END