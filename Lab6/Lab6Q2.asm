ORG 0000H
LJMP MAIN
ORG 0100H
	MAIN:
MOV R2,#0F1H
MOV R3,#89H
ACALL TWOSECDELAY
MOV R2,#0F2H
MOV R3,#0FBH
ACALL TWOSECDELAY
LJMP MAIN
DELAY1: MOV TMOD,#00010001B 
       MOV TH0,R2
       MOV TL0,R3 
       SETB TR0 
HERE1: JNB TF0,HERE1
      CLR TR0 
      CLR TF0 
      RET
TWOSECDELAY:MOV R6,#80
DELAYLOOP: ACALL DELAY2
      DJNZ R6,DELAYLOOP
      LJMP NEXT2
DELAY2: MOV TMOD,#00010001B 
       MOV TH1,#3CH
       MOV TL1,#0B0H 
       SETB TR1 
HERE2: 
RE:SETB P0.0
ACALL DELAY1
CLR P0.0
ACALL DELAY1
JNB TF1,HERE2
      CLR TR1 
      CLR TF1 
      RET
	  NEXT2:RET
	  
	  END