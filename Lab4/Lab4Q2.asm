FINISH:MOV P1,#00001111B
ACALL ROUTINE
SJMP FINISH

ROUTINE:MOV P1,#0FFH
MOV R2,#5H
INPUTN:ACALL ONESECDELAY
DJNZ R2,INPUTN
MOV A,P1
ANL A,#00001111B
JNZ NZ
MOV A,#01H
NZ:MOV R2,A

BLINK:MOV P1,#00000000B
ACALL ONESECDELAY
MOV P1,#11110000B
ACALL ONESECDELAY
DJNZ R2,BLINK
RET


ONESECDELAY:MOV R6,#40
DELAYLOOP: 
	  ACALL DELAY
      DJNZ R6,DELAYLOOP
      LJMP NEXT2
DELAY: MOV TMOD,#00000001B 
       MOV TH0,#3CH
       MOV TL0,#0B0H 
       SETB TR0 
HERE: JNB TF0,HERE 
      CLR TR0 
      CLR TF0 
      RET
	  NEXT2:RET
END