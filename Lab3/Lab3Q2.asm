CASE1OR4: JNB P1.0,CASE2
SETB P1.4
JNB P1.1,NEXT1
SETB P1.6
NEXT1:ACALL ONESECDELAY
CLR P1.4
ACALL ONESECDELAY
CLR P1.6
ACALL ONESECDELAY
ACALL ONESECDELAY
CLR P1.4
SJMP CASE1OR4
CASE2:JNB P1.1,CASE3
SETB P1.6
ACALL ONESECDELAY
ACALL ONESECDELAY
CLR P1.6
ACALL ONESECDELAY
ACALL ONESECDELAY
LJMP CASE1OR4
CASE3:CLR P1.4
CLR P1.6
LJMP CASE1OR4

ONESECDELAY:MOV R6,#40
DELAYLOOP: 
	  ACALL DELAY
      DJNZ R6,DELAYLOOP
      LJMP NEXT2
DELAY: MOV TMOD,#00000001B 
       MOV TH0,#3CH
       MOV TL0,#0B0H 
       SETB TR0 
HERE: JNB TF0,HERE 
      CLR TR0 
      CLR TF0 
      RET
	  NEXT2:RET
END

	
